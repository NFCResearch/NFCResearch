options:
  parameters:
    generate_options: qt_gui
    id: CollectData
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: card
  id: variable
  parameters:
    value: '52'
  states: {}
- name: center_frequency
  id: variable
  parameters:
    value: 13.5e6
  states: {}
- name: rx_fs
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: tx_fs
  id: variable
  parameters:
    value: 12.5e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\akamrath2\Documents\Research_Summer2024\DataCollection\GNURadio\Data\rx_data.dat
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      This block will take in the input parameters and generate the sampled data
      for the corresponding command. It will then add a RF Reset (just an array of 0's)
      after the command portion is outputted.

      Inputs:

      Tx_fs: Transmit Frequency for the data generated
      Ask_percent: Multiplication factor used to Amplitude Shift Keying (between 0.1 and 1.0)
      Command_code: Hex Value used for the command generated according to ISO15693 Documentation
      Mask_Length: Mask Length used for Inventory command
      flagBits: 8 binary values used for command flag bits according to ISO15693 Documentation, this
                  is updated automatically by the 'save card signals' block.

      Outputs:

      out_sig: Samples for command transmission
      tx_len: length of the sampled command array. Used when saving tag signals after reception
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import logging

      logger = logging.getLogger('grc')
      logging.basicConfig(level=logging.DEBUG)

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, tx_fs=12.5e6, ask_percent=1.0, commandCode=0b00000001, maskLength=0b00000000):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Generate Command Data',   # will show up in GRC
                  in_sig=[],
                  out_sig=[np.complex64]
              )
              # Variables that persist over multiple work calls
              self.tx_fs = tx_fs
              self.ask_percent = ask_percent
              self.flagBits = '00100100'
              self.commandCode = commandCode
              self.maskLength = maskLength
              self.data_generated = False
              self.command_data = None
              self.command_data_len = 0
              self.current_index = 0

              #Tx_len output and flagBits input setup
              self.message_port_register_out(pmt.intern("tx_len"))
              self.message_port_register_in(pmt.intern("flagBits"))
              self.set_msg_handler(pmt.intern("flagBits"), self.handle_msg)

          def work(self, input_items, output_items):
              
              ## Generate Data if it has not already been
              if not self.data_generated:
                  logger.debug("Flagbits: " + self.flagBits)
                  flagBits = int(self.flagBits,2) # Convert flagBits string to int
                  self.command_data = generateCommandData(self.tx_fs, self.ask_percent, flagBits, self.commandCode, self.maskLength) # Generate command data
                  self.command_data_len = len(self.command_data)
                  self.message_port_pub(pmt.intern("tx_len"), pmt.from_long(self.command_data_len)) # Change the tx_len output to correspond with new data
                  self.data_generated = True
                  logger.debug("DATA GENERATED")
              
              num_output_items = len(output_items[0])
              end_index = self.current_index + num_output_items
              
              ## Setting output items. Can only output 4096 items per work call. This keeps track of the index of the array to ensure we are outputting the correct data
              try:
                  if end_index <= self.command_data_len:
                      output_items[0][:] = self.command_data[self.current_index:end_index]
                      self.current_index = end_index
                  else:
                      remaining_items = self.command_data_len - self.current_index
                      output_items[0][:remaining_items] = self.command_data[self.current_index:self.command_data_len]
                      output_items[0][remaining_items:] = self.command_data[:num_output_items - remaining_items]
                      self.current_index = num_output_items - remaining_items
              except:
                  self.data_generated = False
                  self.command_data_len = 0
                  self.current_index = 0
                  remaining_items = 0
                  output_items[0][:] = 0
                  return 0
              return len(output_items[0])


          #Get flagBits from generate command data block
          def handle_msg(self, msg):
              prevFlagBits = self.flagBits
              if prevFlagBits != str(msg):
                  logger.debug("CHANGING FLAGBITS")
                  self.flagBits = str(msg)
                  self.data_generated = False

      #Takes in the input parameters and creates an array with the neccessary command data
      def generateCommandData(tx_fs, ask_percent, flagBits, commandCode, maskLength):

          rf_reset_length = round((8160e-6)/(1/tx_fs))
          data_bytes = [flagBits, commandCode, maskLength]
          CRC = calculateCRC(data_bytes)

          ## Rearrange Bits for Transmission
          flagBits = bin(flagBits)[2:].zfill(8)
          commandCode = bin(commandCode)[2:].zfill(8)
          maskLength = bin(maskLength)[2:].zfill(8)

          rearranged_flagBits = ''
          for i in range(len(flagBits) - 1, 0, -2):
              bitpair = flagBits[i-1:i+1]
              rearranged_flagBits = rearranged_flagBits + bitpair

          rearranged_commandCode = ''
          for i in range(len(commandCode) - 1, 0, -2):
              bitpair = commandCode[i-1:i+1]
              rearranged_commandCode = rearranged_commandCode + bitpair

          rearranged_maskLength = ''
          for i in range(len(maskLength) - 1, 0, -2):
              bitpair = maskLength[i-1:i+1]
              rearranged_maskLength = rearranged_maskLength + bitpair

          rearranged_CRC = ''
          for i in range(len(CRC) - 1, 0, -2):
              bitpair = CRC[i-1:i+1]
              rearranged_CRC = rearranged_CRC + bitpair

          # Get the correct binary code for the command
          command = rearranged_flagBits + rearranged_commandCode + rearranged_maskLength + rearranged_CRC
          
          #Modulates the data
          command_data = modulateCommand(command, tx_fs, ask_percent)
          command_data = modulateSOF_EOF(command_data, tx_fs, ask_percent)
          command_data = modulateSlotData(command_data, tx_fs, ask_percent, flagBits)
          
          #Add RF Reset after the command data
          command_data = np.append(command_data, np.zeros(rf_reset_length,))
          
          # Embedded the command into a sine wave for ASK Modulation
          command_data = addSineWave(command_data, tx_fs, 60000)
          return command_data

      # Gets the hex values for the CRC put at the end of the command. This changes everytime any command binary value is changed
      def calculateCRC(data_bytes):
          # Constants
          POLYNOMIAL = 0x8408  # x^16 + x^12 + x^5 + 1
          PRESET_VALUE = 0xFFFF
          NUMBER_OF_BYTES = len(data_bytes)
          
          current_crc_value = PRESET_VALUE
          
          for i in range(NUMBER_OF_BYTES):
              current_crc_value = current_crc_value ^ (data_bytes[i])
              for j in range(8):
                  if (current_crc_value & 0x0001):
                      current_crc_value = (current_crc_value >> 1) ^ POLYNOMIAL
                  else:
                      current_crc_value = current_crc_value >> 1

          inverted_crc_value = ~current_crc_value
          unsigned_integer = inverted_crc_value+(1 << 16) 
          CRC = bin(unsigned_integer)[2:].zfill(16)

          return CRC

      # Using the hex values for the binary command, gets an array of 1's and 0's according to ISO15693 documentation        
      def modulateCommand(command, tx_fs, ask_percent):
          
          pair_samples = round((75.52e-6)/(1/tx_fs))
          low_percent = 1 - ask_percent
          low_samples = round((9.44e-06)/(1/tx_fs))
          low_data = np.ones(low_samples) * low_percent
          
          data = []
          for i in range(0, len(command), 2):
              pair = command[i:i+2]
              pair_data = np.ones(pair_samples)
              match pair:
                  case "00":
                      high_samples = round((9.44e-06)/(1/tx_fs))
                      pair_data[high_samples:high_samples+low_samples] = low_data
                  case "01":
                      high_samples = round((28.32e-06)/(1/tx_fs))
                      pair_data[high_samples:high_samples+low_samples] = low_data
                  case "10":
                      high_samples = round((47.2e-06)/(1/tx_fs))
                      pair_data[high_samples:high_samples+low_samples] = low_data
                  case "11":
                      high_samples = round((66.08e-06)/(1/tx_fs))
                      pair_data[high_samples:high_samples+low_samples] = low_data
              data = np.append(data, pair_data)
          return data

      # Gets array of 1's and 0's for Start of Frame and End of Frame
      def modulateSOF_EOF(data, tx_fs, ask_percent):
          SOF_length = round((75.52e-06)/(1/tx_fs))
          EOF_length = round(SOF_length/2)
          
          low_percent = 1-ask_percent
          low_samples = round((9.44e-06)/(1/tx_fs))
          low_data = np.ones(low_samples) * low_percent

          SOF = np.ones(SOF_length)
          SOF[:low_samples] = low_data
          high_samples = round((47.2e-06)/(1/tx_fs))
          SOF[high_samples:high_samples+low_samples] = low_data

          EOF = np.ones(EOF_length)
          high_samples = round((18.88e-06)/(1/tx_fs))
          EOF[high_samples:high_samples + low_samples] = low_data

          data = np.append(SOF, data)
          data = np.append(data, EOF)
          return data

      # Adds slots to data according to flagBits
      def modulateSlotData(data, tx_fs, ask_percent, flagBits):
          slot_flag = flagBits[2]
          rate_flag = flagBits[6]
          inv_flag = flagBits[5]
          
          low_percent = 1-ask_percent
          low_samples = round((9.44e-06)/(1/tx_fs))
          low_data = np.ones(low_samples) * low_percent

          EOF_length = round((37.76e-06)/(1/tx_fs))
          EOF = np.ones(EOF_length)
          high_samples = round((18.88e-06)/(1/tx_fs))
          EOF[high_samples:high_samples + low_samples] = low_data

          if (rate_flag == '1'):
              slot_length = round(8160e-06/(1/tx_fs))
          else:
              slot_length = round(20332e-06/(1/tx_fs))
          slot = np.ones(slot_length)
          data = np.append(slot, data)
          if (slot_flag == '0' and inv_flag == '1'):
              slot = np.append(slot,EOF)
              for i in range(16):
                  data = np.append(data, slot)
          else:
              data = np.append(data, np.ones(slot_length))
          return data

      # Adds ASK Modulation to data
      def addSineWave(data, tx_fs, sinewave_fs):
          data_length = len(data)
          duration = data_length / tx_fs
          t = np.linspace(0, duration, data_length, endpoint=False, dtype=np.complex64)  # Time array

          # Generate the complex sine wave
          sine_wave = np.exp(2j * np.pi * sinewave_fs * t).astype(np.complex64)
          data = sine_wave * data
          return data
    ask_percent: '1.0'
    commandCode: '0x01'
    maskLength: '0b00000000'
    tx_fs: tx_fs
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nThis block will fill a buffer and then search the buffer for tag signals.\nThis will continue until the neccessary amount of card signals is found.\nThen is will change the flagBits for command generate and start again.\n\nInputs:\n\nRx_fs: Receiving frequency used to know the timing of the received signal\nTx_fs: Transmit frequency used to know the timing of the transmitted signal\nsignals_requested: How many signals to find and stop after (for each response combination)\nCard: The card used to save data from\n\nOutputs:\n\nflagBits: used to change what command is being transmitted. Connected to generate command data block\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport logging\nimport os\nfrom pathlib import Path\nfrom scipy.stats.stats import pearsonr \n\nlogger = logging.getLogger('grc')\nlogging.basicConfig(level=logging.DEBUG)\n\nclass SaveNumpyArrayBlock(gr.sync_block):\n    def __init__(self, rx_fs=2e6, tx_fs=12.5e6, signals_requested = 100, card = 1):\n        gr.sync_block.__init__(\n            self,\n            name='Save Card Signals',\n            in_sig=[np.complex64],\n            out_sig=[]\n        )\n        ## Make Variables that persistent with each work loop\n        self.data = []\n        self.rx_fs = rx_fs\n        self.tx_fs = tx_fs\n        self.flagBits = ['00100100','00100101','00100110','00100111']\n        self.signals_found = 0\n        self.signals_requested = signals_requested\n        self.tx_len = 0\n        self.card = card\n        self.flagBitsIndex = 0\n        \n        #tx_len and flagbits setup\n        self.message_port_register_in(pmt.intern(\"tx_len\"))\n        self.set_msg_handler(pmt.intern(\"tx_len\"), self.handle_msg)\n        self.message_port_register_out(pmt.intern(\"flagBits\"))\n        self.message_port_pub(pmt.intern(\"flagBits\"), pmt.intern(self.flagBits[0]))        \n        \n    #Get tx_len from generate command data block\n    def handle_msg(self, msg):\n        self.tx_len = pmt.to_long(msg)\n\n    def work(self, input_items, output_items):\n        \n        while self.flagBitsIndex < 4:    \n            #Changing variables based on Data rate and subcarrier number combination\n            flagBits = self.flagBits[self.flagBitsIndex]\n            match flagBits[6:8]:\n                case '00':\n                    data_directory = Path('C:/Users/akamrath2/Documents/Research_Summer2024/DataCollection/GNURadio/Data/OneSubcarrierLowDataRate')\n                    SOF_time = (151.04e-06) * 4\n                    bit_time = (37.76e-06) * 4\n                case '01':\n                    data_directory = Path('C:/Users/akamrath2/Documents/Research_Summer2024/DataCollection/GNURadio/Data/TwoSubcarriersLowDataRate')\n                    SOF_time = (149.85e-06) * 4\n                    bit_time = (37.46e-06) * 4\n                case '10':\n                    data_directory = Path('C:/Users/akamrath2/Documents/Research_Summer2024/DataCollection/GNURadio/Data/OneSubcarrierHighDataRate')\n                    SOF_time = 151.04e-06\n                    bit_time = 37.76e-06\n                case '11':\n                    data_directory = Path('C:/Users/akamrath2/Documents/Research_Summer2024/DataCollection/GNURadio/Data/TwoSubcarriersHighDataRate')\n                    SOF_time = 149.85e-06\n                    bit_time = 37.46e-06\n\n            # Define file paths\n            os.makedirs(data_directory, exist_ok=True)\n            card_name = 'card' + str(self.card) + '.npy'\n            self.card_sig_path = data_directory / card_name\n            self.corr_sig_path = data_directory / 'corr_signal.npy'\n\n            SOF_length = round(SOF_time/(1/self.rx_fs))\n            bit_length = round(bit_time/(1/self.rx_fs))\n            response_bits = 8\n            response_length = SOF_length + (bit_length * (response_bits))\n\n            #Create files if they don't exist\n            if not self.card_sig_path.is_file():\n                np.save(self.card_sig_path,  np.zeros((0,response_length), dtype=np.complex64))\n\n            self.corr_signal = np.load(self.corr_sig_path, allow_pickle=True)\n\n            # Collect incoming samples\n            \n            # Runs when enough data is collected and stored\n            if len(self.data) >= 2000000:\n                \n                prev_cards = np.load(self.card_sig_path, allow_pickle=True)\n                self.signals_found = prev_cards.shape[0]\n                buffer = np.array(self.data, dtype=np.complex64)\n                try:\n                    card_signals = findCardSignals(buffer, self.rx_fs, self.tx_fs, flagBits, self.tx_len) # Finds all possible card signals from collected data\n                    card_signals = normalize_data(self, card_signals) # Makes sure they all have the same mean\n                except:\n                    self.data = []\n                    return 0\n                ## Removes card signals that are not similar to the correlation signal (a known card signal)\n                row_to_remove = []\n                for i in range(card_signals.shape[0]):\n                    diff = pearsonr(np.abs(self.corr_signal), np.abs(card_signals[i]))[0]\n                    if diff < 0.8:\n                        row_to_remove.append(i)\n                card_signals = np.delete(card_signals, row_to_remove, axis=0)\n\n                ## Finds how signals we still need to find\n                signals_remaining = self.signals_requested - self.signals_found\n                if signals_remaining > card_signals.shape[0]:\n                    signals_remaining = card_signals.shape[0]\n                \n                ## Adds and saves newly found signals\n                card_signals = np.vstack((prev_cards, card_signals[:signals_remaining]))\n                self.signals_found = card_signals.shape[0]\n                logger.debug(\"Signals Found: \" + str(self.signals_found))\n                np.save(self.card_sig_path, card_signals)\n\n                ## Checks if all signals are found\n                if self.signals_found >= self.signals_requested:\n                    card_signals = normalize_data(self, card_signals)\n                    np.save(self.card_sig_path, card_signals)\n                    logger.debug(\"-------FLAGBITS: \" + str(self.flagBits[self.flagBitsIndex]) + \" COMPLETED-------\")\n                    self.flagBitsIndex = self.flagBitsIndex + 1\n                    self.message_port_pub(pmt.intern(\"flagBits\"), pmt.intern(self.flagBits[self.flagBitsIndex]))\n                    self.data = []\n                else:\n                    self.data = []\n                return 0\n            ## Collects data\n            elif len(self.data) <= 2000000:\n                self.data.extend(input_items[0])\n                return len(input_items[0])\n            return 0\n        return 0\n            \ndef findCardSignals(data,rx_fs, tx_fs, flagBits, tx_len):\n    abs_data = np.abs(data)\n\n    ## Gets the correct timings of received data\n    rate_flag = flagBits[6]\n    if rate_flag == '1':\n        slot_length = round(8160e-06/(1/rx_fs))\n    else:\n        slot_length = round(20332e-06/(1/rx_fs))\n    rf_reset_length = round(8160e-06/(1/rx_fs))\n    command_time = tx_len / tx_fs\n    command_length = round((command_time/(1/rx_fs)) + (2.5e-04/(1/rx_fs)))\n    N = 50\n    rho = 15\n\n    match flagBits[6:8]:\n        case '00':\n            SOF_time = (151.04e-06) * 4\n            SOF_low_time = (56.64e-06) * 4\n            bit_time = (37.76e-06) * 4\n        case '01':\n            SOF_time = (149.85e-06) * 4\n            SOF_low_time = 0\n            bit_time = (37.46e-06) * 4\n        case '10':\n            SOF_time = 151.04e-06\n            SOF_low_time = 56.64e-06\n            bit_time = 37.76e-06\n        case '11':\n            SOF_time = 149.85e-06\n            SOF_low_time = 0\n            bit_time = 37.46e-06\n\n    SOF_length = round(SOF_time/(1/rx_fs))\n    SOF_low_length = round(SOF_low_time/(1/rx_fs))\n    bit_length = round(bit_time/(1/rx_fs))\n    response_bits = 8\n    response_length = SOF_length + (bit_length * (response_bits))\n    tx_start = 0\n    card_signals = [None] * response_length\n    ## Finds when the received signal is Low\n    start = findRFreset(data)\n    data = data[start:]\n    ## Loops through data to find all the card signals\n    while ((tx_start+(2*command_length)) < len(abs_data)):\n        abs_data = np.abs(data)\n        # Finds when data goes high (start of command transmission)\n        for i in range(0,len(abs_data), 100):\n            window_size = 100\n            if (i + window_size) > (len(abs_data) - 1):\n                window_size = len(abs_data) - i - 1\n            delta = np.abs(abs_data[i+window_size] - abs_data[i])\n            if delta > 0.1:\n                tx_start = i\n                break\n            tx_start = None\n        if (tx_start is None):\n            return card_signals[1:]\n        \n        offset = tx_start + (command_length - slot_length - rf_reset_length) # Finds end of command transmission\n        # Finds the start of the card response\n        response_start = findResponseStart(data[offset:], N , rho)\n        offset = offset + response_start - SOF_low_length\n        \n        # Gets card signal\n        card_signal = data[offset:offset + response_length]\n        card_signals = np.vstack((card_signals,card_signal))\n        \n        # Finds the next time transmission pauses\n        data = data[tx_start + command_length - rf_reset_length:]\n        start = findRFreset(data)\n        data = data[start:]\n    return card_signals[1:]\n    \n#Finds when the start of tag response starts\ndef findResponseStart(data, N, rho):\n    data = np.abs(data)\n    delta = np.abs(np.diff(data))\n    midPoint = int(np.floor(N/2) + 1)\n    deltaSegment = delta[midPoint:N]\n    sigma = rho * np.mean(deltaSegment)\n    start = np.where(delta > sigma)[0][0]\n    return start\n\n#Finds when data goes low for period of time\ndef findRFreset(data):\n    window_size = 1000\n    for i in range(0, len(data), window_size):\n            avg = np.mean(abs(data[i:i+window_size]))\n            if avg <= 0.001:\n                return i\n\n## Uses a sliding window and mean to find how similar two arrays are           \ndef differences(arr1, arr2):\n    windows_size = 10\n    diffs = []\n    for i in range(0,len(arr1)-windows_size, windows_size):\n        arr1_mean = np.mean(np.abs(arr1[i:i+windows_size]))\n        arr2_mean = np.mean(np.abs(arr2[i:i+windows_size]))\n        diff = np.abs(arr1_mean - arr2_mean)\n        diffs = np.append(diffs, diff)\n    return np.mean(diffs)\n\n## Makes the input array have the same mean as correlation signal\ndef normalize_data(self, data):\n    data = np.asarray(data, np.complex_)\n    overall_mean_magnitude = np.mean(np.abs(self.corr_signal))\n    row_means = np.mean(np.abs(data), axis=1)\n    normalized_data = np.empty_like(data, dtype=np.complex_)\n    for i in range(data.shape[0]):\n        magnitudes = np.abs(data[i])\n        phases = np.angle(data[i])\n\n        scale_factor = overall_mean_magnitude / row_means[i]\n\n        new_magnitudes = magnitudes * scale_factor\n\n        normalized_data[i] = new_magnitudes * np.exp(1j * phases)\n    return normalized_data\n    \n\n"
    card: card
    rx_fs: '2000000.0'
    signals_requested: '500'
    tx_fs: '12500000.0'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: rx_fs
    fc: center_frequency
    fftsize: '2048'
    rate: '10000'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '630596'
    srate: rx_fs
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_frequency
    gain0: '0'
    samp_rate: tx_fs
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 'center_frequency '
    gain0: '0'
    samp_rate: rx_fs
    sync: none
    type: fc32
  states: {}

connections:
- [epy_block_0, '0', uhd_usrp_sink_0, '0']
- [epy_block_0, tx_len, epy_block_1, tx_len]
- [epy_block_1, flagBits, epy_block_0, flagBits]
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', epy_block_1, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
